TOOLCHAIN = "gcc"
PACKAGECONFIG = "lapack cblas affinity dynarch"